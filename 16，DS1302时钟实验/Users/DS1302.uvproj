# Keil uVision project DS1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\bsp_ds1302;..\Public;..\App\bsp_smg
  group Users
    ./: main.c
  group Public
    ../Public/: public.c
  group App
    ../App/bsp_smg/: smg.c
    ../App/bsp_ds1302/: ds1302.c

# Keil uVision project EEPROM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\bsp_24c02;..\Public;..\App\bsp_iic;..\App\bsp_key;..\App\bsp_smg
  group Users
    ./: main.c
  group Public
    ../Public/: public.c
  group App
    ../App/bsp_24c02/: 24c02.c
    ../App/bsp_iic/: iic.c
    ../App/bsp_key/: key.c
    ../App/bsp_smg/: smg.c

# Keil uVision project Step_Motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Step_Motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\bsp_step_motor;..\Public;..\App\bsp_key
  group Users
    ./: main.c
  group Public
    ../Public/: public.c
  group App
    ../App/bsp_step_motor/: step_motor.c
    ../App/bsp_key/: key.c

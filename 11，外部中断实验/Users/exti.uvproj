# Keil uVision project exti.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: exti +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\bsp_led;..\Public;..\App\bsp_key
  group Users
    ./: main.c
  group Public
    ../Public/: public.c
  group App
    ../App/bsp_key/: key.c
    ../App/bsp_led/: led.c

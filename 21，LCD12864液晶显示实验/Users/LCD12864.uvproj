# Keil uVision project LCD12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LCD12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\bsp_lcd12864;..\Public
  group Users
    ./: main.c
  group Public
    ../Public/: public.c
  group App
    ../App/bsp_lcd12864/: lcd12864.c

# Keil uVision project Key_Matrix.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Key_Matrix +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\bsp_key_matrix;..\Public;..\App\bsp_smg
  group Users
    ./: main.c
  group Public
    ../Public/: public.c
  group App
    ../App/bsp_key_matrix/: key_matrix.c
    ../App/bsp_smg/: smg.c
